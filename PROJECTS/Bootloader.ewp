# IAR project Bootloader.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xC ST STM32F103xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\MALLOC; ..\FATFS\exfuns; ..\FATFS\src; ..\FATFS\src\option; ..\user; ..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\Libraries\STM32F10x_StdPeriph_Driver\src; ..\FATFS; ..\USB\LIB; ..\USB\CONFIG; ..\HARDWARE; ..\SYSTEM; ..\USMART; ..\IAP; ..\ZTM_LIB; ..\APP; ..\FreeRTOS; ..\FreeRTOS\include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Bootloader.hex
  ILINK.IlinkOutputFile: Bootloader.out
  ILINK.IlinkIcfFile: STM32F10x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\MALLOC; ..\FATFS\exfuns; ..\FATFS\src; ..\FATFS\src\option; ..\user; ..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\Libraries\STM32F10x_StdPeriph_Driver\src; ..\FATFS; ..\USB\LIB; ..\USB\CONFIG; ..\HARDWARE; ..\SYSTEM; ..\USMART; ..\IAP; ..\ZTM_LIB
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: fatfs.bin
  ILINK.IlinkOutputFile: fatfs.out
  ILINK.IlinkIcfFile: E:\lison chan\my_program\du fatfs usb iap lcd\PROJECTS\stm32f10x_flash.icf
  group APP
    ../APP/: fatfs.c lcd.c menu.c time_display.c usb.c
  group FATFS
    ../FATFS/src/option/: ccsbcs.c
    ../FATFS/src/: diskio.c ff.c
    ../FATFS/exfuns/: exfuns.c
  group FreeRTOS
    ../FreeRTOS/: FreeRTOSConfig.h heap_2.c list.c port.c portasm.s queue.c tasks.c
  group FWLIB/CMSIS/Startup
    ./: startup_stm32f10x_hd.s
  group FWLIB/scr
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group HARDWARE
    ../HARDWARE/: bkp.c bsp_rtc_1302.c flash.c iwdg.c key.c spi.c stmflash.c timer.c
  group IAP
    ../IAP/: iap.c
  group MALLOC
    ../MALLOC/: malloc.c
  group SYSTEM
    ../SYSTEM/: bsp_usart.c delay.c sys.c usart.c
  group USB/CONFIG
    ../USB/CONFIG/: hw_config.c mass_mal.c memory.c scsi_data.c stm32_it.c usb_bot.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usb_scsi.c
  group USB/LIB
    ../USB/LIB/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group USER
    ./: main.c stm32f10x_conf.h stm32f10x_it.c system_stm32f10x.c
  group ZTM
    ../ZTM_LIB/: ZTM.h ZTM_API.c ZTM_DRV.c
